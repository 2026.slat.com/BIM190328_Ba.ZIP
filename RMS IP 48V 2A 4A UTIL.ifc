Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-06-25T07:45:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 25 07:45:45 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{F6BD249C-37A5-4742-8FFB-812D71254327}\ifc * Database version: 5507 * Database creation date: Tue Jun 25 07:45:43 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 25 07:45:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 25 07:45:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: RMS IP 48V 2A 4A UTIL, RMS IP 48V 2A 4A UTIL:RMS IP 48V 2A 4A UTIL:138195
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 1580434000; datBIM.Code produit SLAT (Id SlatEntityCode): 1580434000; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Consommation electrique (Primary current): 2; datBIM.Couleur dominante (Dominant color): Gris PANTONE 427C (Grey PANTONE 427C); datBIM.Courant maximal d'utilisation (Maximal output current): 6; datBIM.Degre d'etancheite IP (Protection class IP): IP30; datBIM.Description longue entité: <p> <img title="RMS IP avant bd.jpg" src="https://admin.datbim.com/media/mid/1/22979.jpg" alt="" width="243" height="107" data-idmedia="22979" /></p><p><em>Ref. : 1580434000<br /></em></p><p>Les alimentations sécurisées de la gamme EVOLUTION IP ? RMS IP fournissent l?énergie permanente d?alimentation et de secours pour toutes les installations / The emergency power supplies of the EVOLUTION ? RMS IP range provide permanent and backup power for all installations.</p>; datBIM.Designation technique (Technical designation): AES, EAE, EAES; datBIM.Duree de la garantie (Length of warranty): 3 ans; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Fonction generique (Generic function): Alimentation électrique (Power supply); datBIM.Hauteur (Height): 84.6 mm; datBIM.Hauteur hors tout (Height overall): 88.1 mm; datBIM.Id: datBIM:383878; datBIM.Largeur (Wide): 428 mm; datBIM.Largeur hors tout (Wide overall): 482.6 mm; datBIM.Libellé entité: RMS IP 48V 2A 4A UTIL; datBIM.Longueur (Length): 356.4 mm; datBIM.Longueur hors tout (Length overall): 356.4 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Aluminium - Acier (Aluminium - steel); datBIM.Mode de communication (Communication mode): IP; datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 2; datBIM.Poids (Weight): 3.7; datBIM.Point de fixation (Mounting point): 4; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 300 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommande (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommande (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommande (Recommanded); datBIM.Rendement energetique (Energy efficiency): 90; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -5 à +40 °C; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 98-264 V; datBIM.Tension nominale de sortie (Rated output voltage): 48 V; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Baie /(Bay-mounted); Nom de la famille: RMS IP 48V 2A 4A UTIL
Type - Données d'identification - Fabricant: SLAT; Nom du type: RMS IP 48V 2A 4A UTIL
Pset_BuildingElementProxyCommon - Reference: RMS IP 48V 2A 4A UTIL
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: RMS IP 48V 2A 4A UTIL: RMS IP 48V 2A 4A UTIL; Famille et type: RMS IP 48V 2A 4A UTIL: RMS IP 48V 2A 4A UTIL; ID du type: RMS IP 48V 2A 4A UTIL: RMS IP 48V 2A 4A UTIL; Type: RMS IP 48V 2A 4A UTIL: RMS IP 48V 2A 4A UTIL
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.263959 m2; Volume: 0.0124697 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
